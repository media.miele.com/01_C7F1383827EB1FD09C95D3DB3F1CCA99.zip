Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 0693e99e-23b4-4939-81e5-5998c2e0810e, NumberOfSaves: 1]
File name: 0001
Time: 2025-07-28T12:28:33+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11605150_EP2_PFD103SCiXXL_ED:61010304_EP2_11605150_PFD103SCiXXL_ED, (2)
In: Default
Type - Material: z_Miele_Connection_Liquid Detergent, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, Polypropylene, z_Miele_Design_Glass Black, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 61010304_EP2_11605150_PFD103SCiXXL_ED; sets with these values: 2

# IfcDistributionPort, Port_356522_1
Description: Flow; FlowDirection: SOURCEANDSINK
